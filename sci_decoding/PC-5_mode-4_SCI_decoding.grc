options:
  parameters:
    author: samswin
    generate_options: qt_gui
    id: PC_5_mode_4_SCI_decoding
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: high_pass_cutoff_frequency
  id: variable_qtgui_range
  parameters:
    label: High Pass Cutoff
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: 200e3
  states: {}
- name: high_pass_transition_width
  id: variable_qtgui_range
  parameters:
    label: Transition Width
    start: '0'
    step: '1'
    stop: 20e6
    value: 40e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 7e6
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tuning
  id: variable
  parameters:
    value: 5.915e9
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/samswin/Sam Wiki/2023 Immerse Summer Internship/attachments/BSM Hello World Project/2023-06-29_OBU.cf64
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-180000'
    sample_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: high_pass_cutoff_frequency
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: high_pass_transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '40'
    type: complex
    update_time: '0.0010'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    name: '"Original Signal"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: tuning
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
